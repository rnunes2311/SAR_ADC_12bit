v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 100 -820 900 -420 {flags=graph
y1=-0.043
y2=2.8
ypos1=-0.04
ypos2=1.9
divy=5
subdivy=1
unity=1
x1=1.4079812e-05
x2=1.4161414e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


digital=0









color="11 6 7 13"
node="vdac_p
vdac_n
en_vin_bstr_p
vin_p"}
N 4130 640 4130 720 {
lab=C10_P_btm}
N 3790 640 3790 720 {
lab=C9_P_btm}
N 3790 640 3790 720 {
lab=C9_P_btm}
N 3450 640 3450 720 {
lab=C8_P_btm}
N 3110 640 3110 720 {
lab=C7_P_btm}
N 2770 640 2770 720 {
lab=C6_P_btm}
N 2430 640 2430 720 {
lab=C5_P_btm}
N 2090 640 2090 720 {
lab=C4_P_btm}
N 1750 640 1750 720 {
lab=C3_P_btm}
N 1410 640 1410 720 {
lab=C2_P_btm}
N 1070 640 1070 720 {
lab=C1_P_btm}
N 730 640 730 720 {
lab=C0_P_btm}
N 390 640 390 720 {
lab=C0_dummy_P_btm}
N 30 440 310 440 {
lab=VIN_P}
N 310 440 310 500 {
lab=VIN_P}
N 650 440 650 500 {
lab=VIN_P}
N 310 440 650 440 {
lab=VIN_P}
N 690 400 690 500 {
lab=VREF}
N 350 400 350 500 {
lab=VREF}
N 730 360 730 500 {
lab=VSS}
N 390 360 390 500 {
lab=VSS}
N 30 320 430 320 {
lab=VCM}
N 430 320 430 500 {
lab=VCM}
N 770 320 770 500 {
lab=VCM}
N 430 320 770 320 {
lab=VCM}
N 30 360 390 360 {
lab=VSS}
N 30 400 350 400 {
lab=VREF}
N 350 400 690 400 {
lab=VREF}
N 390 360 730 360 {
lab=VSS}
N 990 440 990 500 {
lab=VIN_P}
N 650 440 990 440 {
lab=VIN_P}
N 1030 400 1030 500 {
lab=VREF}
N 1070 360 1070 500 {
lab=VSS}
N 1110 320 1110 500 {
lab=VCM}
N 770 320 1110 320 {
lab=VCM}
N 690 400 1030 400 {
lab=VREF}
N 730 360 1070 360 {
lab=VSS}
N 1330 440 1330 500 {
lab=VIN_P}
N 990 440 1330 440 {
lab=VIN_P}
N 1370 400 1370 500 {
lab=VREF}
N 1410 360 1410 500 {
lab=VSS}
N 1450 320 1450 500 {
lab=VCM}
N 1110 320 1450 320 {
lab=VCM}
N 1030 400 1370 400 {
lab=VREF}
N 1070 360 1410 360 {
lab=VSS}
N 1670 440 1670 500 {
lab=VIN_P}
N 1330 440 1670 440 {
lab=VIN_P}
N 1710 400 1710 500 {
lab=VREF}
N 1750 360 1750 500 {
lab=VSS}
N 1790 320 1790 500 {
lab=VCM}
N 1450 320 1790 320 {
lab=VCM}
N 1370 400 1710 400 {
lab=VREF}
N 1410 360 1750 360 {
lab=VSS}
N 2010 440 2010 500 {
lab=VIN_P}
N 1670 440 2010 440 {
lab=VIN_P}
N 2050 400 2050 500 {
lab=VREF}
N 2090 360 2090 500 {
lab=VSS}
N 2130 320 2130 500 {
lab=VCM}
N 1790 320 2130 320 {
lab=VCM}
N 1710 400 2050 400 {
lab=VREF}
N 1750 360 2090 360 {
lab=VSS}
N 2350 440 2350 500 {
lab=VIN_P}
N 2010 440 2350 440 {
lab=VIN_P}
N 2390 400 2390 500 {
lab=VREF}
N 2430 360 2430 500 {
lab=VSS}
N 2470 320 2470 500 {
lab=VCM}
N 2130 320 2470 320 {
lab=VCM}
N 2050 400 2390 400 {
lab=VREF}
N 2090 360 2430 360 {
lab=VSS}
N 2690 440 2690 500 {
lab=VIN_P}
N 2350 440 2690 440 {
lab=VIN_P}
N 2730 400 2730 500 {
lab=VREF}
N 2770 360 2770 500 {
lab=VSS}
N 2810 320 2810 500 {
lab=VCM}
N 2470 320 2810 320 {
lab=VCM}
N 2390 400 2730 400 {
lab=VREF}
N 2430 360 2770 360 {
lab=VSS}
N 3030 440 3030 500 {
lab=VIN_P}
N 2690 440 3030 440 {
lab=VIN_P}
N 3070 400 3070 500 {
lab=VREF}
N 3110 360 3110 500 {
lab=VSS}
N 3150 320 3150 500 {
lab=VCM}
N 2810 320 3150 320 {
lab=VCM}
N 2730 400 3070 400 {
lab=VREF}
N 2770 360 3110 360 {
lab=VSS}
N 3370 440 3370 500 {
lab=VIN_P}
N 3030 440 3370 440 {
lab=VIN_P}
N 3410 400 3410 500 {
lab=VREF}
N 3450 360 3450 500 {
lab=VSS}
N 3490 320 3490 500 {
lab=VCM}
N 3150 320 3490 320 {
lab=VCM}
N 3070 400 3410 400 {
lab=VREF}
N 3110 360 3450 360 {
lab=VSS}
N 3710 440 3710 500 {
lab=VIN_P}
N 3370 440 3710 440 {
lab=VIN_P}
N 3750 400 3750 500 {
lab=VREF}
N 3790 360 3790 500 {
lab=VSS}
N 3830 320 3830 500 {
lab=VCM}
N 3490 320 3830 320 {
lab=VCM}
N 3410 400 3750 400 {
lab=VREF}
N 3450 360 3790 360 {
lab=VSS}
N 4050 440 4050 500 {
lab=VIN_P}
N 3710 440 4050 440 {
lab=VIN_P}
N 4090 400 4090 500 {
lab=VREF}
N 4130 360 4130 500 {
lab=VSS}
N 4170 320 4170 500 {
lab=VCM}
N 3830 320 4170 320 {
lab=VCM}
N 3750 400 4090 400 {
lab=VREF}
N 3790 360 4130 360 {
lab=VSS}
N -70 440 30 440 {
lab=VIN_P}
N -70 320 30 320 {
lab=VCM}
N -70 360 30 360 {
lab=VSS}
N -70 400 30 400 {
lab=VREF}
N 4250 780 4430 780 {
lab=VDAC_P}
N 4130 920 4130 1000 {
lab=C10_N_btm}
N 3790 920 3790 1000 {
lab=C9_N_btm}
N 3790 920 3790 1000 {
lab=C9_N_btm}
N 3450 920 3450 1000 {
lab=C8_N_btm}
N 3110 920 3110 1000 {
lab=C7_N_btm}
N 2770 920 2770 1000 {
lab=C6_N_btm}
N 2430 920 2430 1000 {
lab=C5_N_btm}
N 2090 920 2090 1000 {
lab=C4_N_btm}
N 1750 920 1750 1000 {
lab=C3_N_btm}
N 1410 920 1410 1000 {
lab=C2_N_btm}
N 1070 920 1070 1000 {
lab=C1_N_btm}
N 730 920 730 1000 {
lab=C0_N_btm}
N 390 920 390 1000 {
lab=C0_dummy_N_btm}
N 30 1200 310 1200 {
lab=VIN_N}
N 310 1140 310 1200 {
lab=VIN_N}
N 650 1140 650 1200 {
lab=VIN_N}
N 310 1200 650 1200 {
lab=VIN_N}
N 690 1140 690 1240 {
lab=VREF}
N 350 1140 350 1240 {
lab=VREF}
N 730 1140 730 1280 {
lab=VSS}
N 390 1140 390 1280 {
lab=VSS}
N 30 1320 430 1320 {
lab=VCM}
N 430 1140 430 1320 {
lab=VCM}
N 770 1140 770 1320 {
lab=VCM}
N 430 1320 770 1320 {
lab=VCM}
N 350 1240 690 1240 {
lab=VREF}
N 390 1280 730 1280 {
lab=VSS}
N 990 1140 990 1200 {
lab=VIN_N}
N 650 1200 990 1200 {
lab=VIN_N}
N 1030 1140 1030 1240 {
lab=VREF}
N 1070 1140 1070 1280 {
lab=VSS}
N 1110 1140 1110 1320 {
lab=VCM}
N 770 1320 1110 1320 {
lab=VCM}
N 690 1240 1030 1240 {
lab=VREF}
N 730 1280 1070 1280 {
lab=VSS}
N 1330 1140 1330 1200 {
lab=VIN_N}
N 990 1200 1330 1200 {
lab=VIN_N}
N 1370 1140 1370 1240 {
lab=VREF}
N 1410 1140 1410 1280 {
lab=VSS}
N 1450 1140 1450 1320 {
lab=VCM}
N 1110 1320 1450 1320 {
lab=VCM}
N 1030 1240 1370 1240 {
lab=VREF}
N 1070 1280 1410 1280 {
lab=VSS}
N 1670 1140 1670 1200 {
lab=VIN_N}
N 1330 1200 1670 1200 {
lab=VIN_N}
N 1710 1140 1710 1240 {
lab=VREF}
N 1750 1140 1750 1280 {
lab=VSS}
N 1790 1140 1790 1320 {
lab=VCM}
N 1450 1320 1790 1320 {
lab=VCM}
N 1370 1240 1710 1240 {
lab=VREF}
N 1410 1280 1750 1280 {
lab=VSS}
N 2010 1140 2010 1200 {
lab=VIN_N}
N 1670 1200 2010 1200 {
lab=VIN_N}
N 2050 1140 2050 1240 {
lab=VREF}
N 2090 1140 2090 1280 {
lab=VSS}
N 2130 1140 2130 1320 {
lab=VCM}
N 1790 1320 2130 1320 {
lab=VCM}
N 1710 1240 2050 1240 {
lab=VREF}
N 1750 1280 2090 1280 {
lab=VSS}
N 2350 1140 2350 1200 {
lab=VIN_N}
N 2010 1200 2350 1200 {
lab=VIN_N}
N 2390 1140 2390 1240 {
lab=VREF}
N 2430 1140 2430 1280 {
lab=VSS}
N 2470 1140 2470 1320 {
lab=VCM}
N 2130 1320 2470 1320 {
lab=VCM}
N 2050 1240 2390 1240 {
lab=VREF}
N 2090 1280 2430 1280 {
lab=VSS}
N 2690 1140 2690 1200 {
lab=VIN_N}
N 2350 1200 2690 1200 {
lab=VIN_N}
N 2730 1140 2730 1240 {
lab=VREF}
N 2770 1140 2770 1280 {
lab=VSS}
N 2810 1140 2810 1320 {
lab=VCM}
N 2470 1320 2810 1320 {
lab=VCM}
N 2390 1240 2730 1240 {
lab=VREF}
N 2430 1280 2770 1280 {
lab=VSS}
N 3030 1140 3030 1200 {
lab=VIN_N}
N 2690 1200 3030 1200 {
lab=VIN_N}
N 3070 1140 3070 1240 {
lab=VREF}
N 3110 1140 3110 1280 {
lab=VSS}
N 3150 1140 3150 1320 {
lab=VCM}
N 2810 1320 3150 1320 {
lab=VCM}
N 2730 1240 3070 1240 {
lab=VREF}
N 2770 1280 3110 1280 {
lab=VSS}
N 3370 1140 3370 1200 {
lab=VIN_N}
N 3030 1200 3370 1200 {
lab=VIN_N}
N 3410 1140 3410 1240 {
lab=VREF}
N 3450 1140 3450 1280 {
lab=VSS}
N 3490 1140 3490 1320 {
lab=VCM}
N 3150 1320 3490 1320 {
lab=VCM}
N 3070 1240 3410 1240 {
lab=VREF}
N 3110 1280 3450 1280 {
lab=VSS}
N 3710 1140 3710 1200 {
lab=VIN_N}
N 3370 1200 3710 1200 {
lab=VIN_N}
N 3750 1140 3750 1240 {
lab=VREF}
N 3790 1140 3790 1280 {
lab=VSS}
N 3830 1140 3830 1320 {
lab=VCM}
N 3490 1320 3830 1320 {
lab=VCM}
N 3410 1240 3750 1240 {
lab=VREF}
N 3450 1280 3790 1280 {
lab=VSS}
N 4050 1140 4050 1200 {
lab=VIN_N}
N 3710 1200 4050 1200 {
lab=VIN_N}
N 4090 1140 4090 1240 {
lab=VREF}
N 4130 1140 4130 1280 {
lab=VSS}
N 4170 1140 4170 1320 {
lab=VCM}
N 3830 1320 4170 1320 {
lab=VCM}
N 3750 1240 4090 1240 {
lab=VREF}
N 3790 1280 4130 1280 {
lab=VSS}
N -70 1200 30 1200 {
lab=VIN_N}
N 4250 860 4430 860 {
lab=VDAC_N}
N 90 400 90 1240 {
lab=VREF}
N 50 360 50 1280 {
lab=VSS}
N 10 330 10 1320 {
lab=VCM}
N 10 320 10 330 {
lab=VCM}
N 90 1240 350 1240 {
lab=VREF}
N 50 1280 390 1280 {
lab=VSS}
N 10 1320 30 1320 {
lab=VCM}
N 4430 860 4590 860 {
lab=VDAC_N}
N 4430 780 4590 780 {
lab=VDAC_P}
N 4470 860 4470 1000 {
lab=VDAC_N}
N 4510 1140 4510 1320 {
lab=VCM}
N 4170 1320 4510 1320 {
lab=VCM}
N 4470 1140 4470 1280 {
lab=VSS}
N 4130 1280 4470 1280 {
lab=VSS}
N 4430 1140 4430 1280 {
lab=VSS}
N 4390 1140 4390 1280 {
lab=VSS}
N 4470 640 4470 780 {
lab=VDAC_P}
N 4510 320 4510 500 {
lab=VCM}
N 4470 360 4470 500 {
lab=VSS}
N 4430 360 4430 500 {
lab=VSS}
N 4390 360 4390 500 {
lab=VSS}
N 4170 320 4510 320 {
lab=VCM}
N 4430 360 4470 360 {
lab=VSS}
N 4390 360 4430 360 {
lab=VSS}
N 4130 360 4390 360 {
lab=VSS}
N 1340 -190 1360 -190 {
lab=SMPL}
N 1340 -160 1360 -160 {
lab=VIN_P}
N 1480 -190 1500 -190 {
lab=SMPL_ON_P}
N 1480 -160 1500 -160 {
lab=EN_VIN_BSTR_P}
N 1340 0 1360 0 {
lab=SMPL}
N 1340 30 1360 30 {
lab=VIN_N}
N 1480 0 1500 0 {
lab=SMPL_ON_N}
N 1480 30 1500 30 {
lab=EN_VIN_BSTR_N}
N 1220 -190 1340 -190 {
lab=SMPL}
N 1240 0 1340 0 {
lab=SMPL}
N 1240 -190 1240 0 {
lab=SMPL}
N 1060 -190 1220 -190 {
lab=SMPL}
C {devices/vsource.sym} 320 -90 0 0 {name=V1 value=1.8 savecurrent=true}
C {devices/lab_wire.sym} 320 -60 2 1 {name=p11 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 320 -120 0 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} 400 -90 0 0 {name=V2 value=0.6 savecurrent=true}
C {devices/lab_wire.sym} 400 -60 2 1 {name=p13 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 400 -120 0 0 {name=p14 sig_type=std_logic lab=VCM}
C {devices/vsource.sym} 480 -90 0 0 {name=V3 value=1.2 savecurrent=true}
C {devices/lab_wire.sym} 480 -60 2 1 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 480 -120 0 0 {name=p16 sig_type=std_logic lab=VREF}
C {devices/vsource.sym} 560 -90 0 0 {name=V4 value=0 savecurrent=false}
C {devices/lab_wire.sym} 560 -60 2 1 {name=p17 sig_type=std_logic lab=GND}
C {devices/lab_wire.sym} 560 -120 0 0 {name=p18 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 320 -180 2 1 {name=p19 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 320 -240 0 0 {name=p20 sig_type=std_logic lab=VIN_P}
C {devices/lab_wire.sym} 480 -180 2 1 {name=p21 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 480 -240 0 0 {name=p22 sig_type=std_logic lab=VIN_N}
C {devices/vsource.sym} 480 -210 0 0 {name=V6 value="SIN(0.6 0.6 2.6171875Meg 0 0 0)" savecurrent=false}
C {devices/vsource.sym} 640 -90 0 0 {name=V7 value="pulse(0 1.8 20n 100p 100p 5n 100n)" savecurrent=false}
C {devices/lab_wire.sym} 640 -60 2 1 {name=p23 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 640 -120 0 0 {name=p24 sig_type=std_logic lab=SMPL}
C {devices/code.sym} 80 -160 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
.include /opt/pdk/share/pdk/sky130A/libs.tech/ngspice/sky130_fd_pr__model__r+c.model.spice
.include ~/Desktop/SAR_ADC_12b/CDAC/New_CDAC/CDAC_12bit.spice
*.include ~/Desktop/SAR_ADC_12b/delay_cell/layout/delay_cell.spice
"
spice_ignore=false
place=header}
C {devices/launcher.sym} 360 -380 0 0 {name=h2 
descr="Simulate" 
tclcommand="xschem netlist; xschem simulate"}
C {devices/launcher.sym} 360 -330 0 0 {name=h5
descr="Load waveforms" 
tclcommand="xschem raw_read $netlist_dir/SAR_ADC_12bit_sim.raw tran"
}
C {devices/code.sym} 73.58642578125 -355.07080078125 0 0 {name=NGSPICE
only_toplevel=true
value="
*.save all
.save smpl meas_input vdac_p vdac_n vin_p vin_n en_vin_bstr_p en_vin_bstr_n
*.option method = gear
.option GMIN=1e-12 reltol=1e-5
.control
		set num_threads=8
		tran 1n 27u
		write sampling_distortion.raw
.endc
"}
C {devices/vsource.sym} 320 -210 0 0 {name=V5 value="SIN(0.6 0.6 2.6171875Meg 0 0 180)" savecurrent=false}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/CDAC/CDAC_12bit.sym} 3530 650 2 1 {name=x2}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C10.sym} 4110 580 2 1 {name=x3}
C {devices/lab_wire.sym} 4050 640 2 1 {name=p27 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C9.sym} 3770 580 2 1 {name=x4}
C {devices/lab_wire.sym} 3710 640 2 1 {name=p28 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C8.sym} 3430 580 2 1 {name=x5}
C {devices/lab_wire.sym} 3370 640 2 1 {name=p29 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C7.sym} 3090 580 2 1 {name=x6}
C {devices/lab_wire.sym} 3030 640 2 1 {name=p30 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 2750 580 2 1 {name=x7}
C {devices/lab_wire.sym} 2690 640 2 1 {name=p31 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 2410 580 2 1 {name=x8}
C {devices/lab_wire.sym} 2350 640 2 1 {name=p36 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 2070 580 2 1 {name=x9}
C {devices/lab_wire.sym} 2010 640 2 1 {name=p42 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 1730 580 2 1 {name=x10}
C {devices/lab_wire.sym} 1670 640 2 1 {name=p48 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 1390 580 2 1 {name=x11}
C {devices/lab_wire.sym} 1330 640 2 1 {name=p54 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 1050 580 2 1 {name=x12}
C {devices/lab_wire.sym} 990 640 2 1 {name=p60 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 710 580 2 1 {name=x13}
C {devices/lab_wire.sym} 650 640 2 1 {name=p66 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 370 580 2 1 {name=x14}
C {devices/lab_wire.sym} 310 640 2 1 {name=p72 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} -70 440 0 0 {name=p73 lab=VIN_P}
C {devices/lab_wire.sym} 4210 720 0 1 {name=p75 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} -70 400 0 0 {name=p78 lab=VREF}
C {devices/ipin.sym} -70 320 0 0 {name=p79 lab=VCM}
C {devices/ipin.sym} -70 360 0 0 {name=p80 lab=VSS}
C {devices/lab_wire.sym} 4510 780 0 1 {name=p81 sig_type=std_logic lab=VDAC_P}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/CDAC/CDAC_12bit.sym} 3530 990 0 0 {name=x15}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C10.sym} 4110 1060 0 0 {name=x16}
C {devices/lab_wire.sym} 4050 1000 0 0 {name=p86 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C9.sym} 3770 1060 0 0 {name=x17}
C {devices/lab_wire.sym} 3710 1000 0 0 {name=p92 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C8.sym} 3430 1060 0 0 {name=x18}
C {devices/lab_wire.sym} 3370 1000 0 0 {name=p98 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C7.sym} 3090 1060 0 0 {name=x19}
C {devices/lab_wire.sym} 3030 1000 0 0 {name=p104 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 2750 1060 0 0 {name=x20}
C {devices/lab_wire.sym} 2690 1000 0 0 {name=p110 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 2410 1060 0 0 {name=x21}
C {devices/lab_wire.sym} 2350 1000 0 0 {name=p116 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 2070 1060 0 0 {name=x22}
C {devices/lab_wire.sym} 2010 1000 0 0 {name=p122 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 1730 1060 0 0 {name=x23}
C {devices/lab_wire.sym} 1670 1000 0 0 {name=p128 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 1390 1060 0 0 {name=x24}
C {devices/lab_wire.sym} 1330 1000 0 0 {name=p134 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 1050 1060 0 0 {name=x25}
C {devices/lab_wire.sym} 990 1000 0 0 {name=p140 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 710 1060 0 0 {name=x26}
C {devices/lab_wire.sym} 650 1000 0 0 {name=p146 sig_type=std_logic lab=VDD}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C6.sym} 370 1060 0 0 {name=x27}
C {devices/lab_pin.sym} 250 1100 0 0 {name=p147 lab=HI}
C {devices/lab_pin.sym} 250 1120 0 0 {name=p148 lab=LO}
C {devices/lab_pin.sym} 250 1070 0 0 {name=p151 lab=EN_VIN_BSTR_N}
C {devices/lab_wire.sym} 310 1000 0 0 {name=p152 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} -70 1200 2 1 {name=p153 lab=VIN_N}
C {devices/lab_wire.sym} 4210 920 2 0 {name=p154 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 860 0 1 {name=p160 sig_type=std_logic lab=VDAC_N}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C10.sym} 4450 1060 0 0 {name=x33}
C {devices/lab_pin.sym} 390 960 0 0 {name=p232 sig_type=std_logic lab=C0_dummy_N_btm}
C {devices/lab_pin.sym} 730 960 0 0 {name=p233 sig_type=std_logic lab=C0_N_btm}
C {devices/lab_pin.sym} 1070 960 0 0 {name=p234 sig_type=std_logic lab=C1_N_btm}
C {devices/lab_pin.sym} 1410 960 0 0 {name=p235 sig_type=std_logic lab=C2_N_btm}
C {devices/lab_pin.sym} 1750 960 0 0 {name=p236 sig_type=std_logic lab=C3_N_btm}
C {devices/lab_pin.sym} 2090 960 0 0 {name=p237 sig_type=std_logic lab=C4_N_btm}
C {devices/lab_pin.sym} 2430 960 0 0 {name=p238 sig_type=std_logic lab=C5_N_btm}
C {devices/lab_pin.sym} 2770 960 0 0 {name=p239 sig_type=std_logic lab=C6_N_btm}
C {devices/lab_pin.sym} 3110 960 0 0 {name=p240 sig_type=std_logic lab=C7_N_btm}
C {devices/lab_pin.sym} 3450 960 0 0 {name=p241 sig_type=std_logic lab=C8_N_btm}
C {devices/lab_pin.sym} 3790 960 0 0 {name=p242 sig_type=std_logic lab=C9_N_btm}
C {devices/lab_pin.sym} 4130 960 0 0 {name=p243 sig_type=std_logic lab=C10_N_btm}
C {devices/lab_pin.sym} 390 680 0 0 {name=p244 sig_type=std_logic lab=C0_dummy_P_btm}
C {devices/lab_pin.sym} 730 680 0 0 {name=p245 sig_type=std_logic lab=C0_P_btm}
C {devices/lab_pin.sym} 1070 680 0 0 {name=p246 sig_type=std_logic lab=C1_P_btm}
C {devices/lab_pin.sym} 1410 680 0 0 {name=p247 sig_type=std_logic lab=C2_P_btm}
C {devices/lab_pin.sym} 1750 680 0 0 {name=p248 sig_type=std_logic lab=C3_P_btm}
C {devices/lab_pin.sym} 2090 680 0 0 {name=p249 sig_type=std_logic lab=C4_P_btm}
C {devices/lab_pin.sym} 2430 680 0 0 {name=p250 sig_type=std_logic lab=C5_P_btm}
C {devices/lab_pin.sym} 2770 680 0 0 {name=p251 sig_type=std_logic lab=C6_P_btm}
C {devices/lab_pin.sym} 3110 680 0 0 {name=p252 sig_type=std_logic lab=C7_P_btm}
C {devices/lab_pin.sym} 3450 680 0 0 {name=p253 sig_type=std_logic lab=C8_P_btm}
C {devices/lab_pin.sym} 3790 680 0 0 {name=p254 sig_type=std_logic lab=C9_P_btm}
C {devices/lab_pin.sym} 4130 680 0 0 {name=p255 sig_type=std_logic lab=C10_P_btm}
C {devices/lab_pin.sym} 250 1020 0 0 {name=p259 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 250 1040 0 0 {name=p203 sig_type=std_logic lab=VSS}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/switches/switch_C10.sym} 4450 580 2 1 {name=x34}
C {devices/lab_wire.sym} 4390 1000 0 0 {name=p220 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4390 640 2 1 {name=p221 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 590 1100 0 0 {name=p1 lab=HI}
C {devices/lab_pin.sym} 590 1120 0 0 {name=p2 lab=LO}
C {devices/lab_pin.sym} 590 1070 0 0 {name=p3 lab=EN_VIN_BSTR_N}
C {devices/lab_pin.sym} 590 1020 0 0 {name=p4 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 590 1040 0 0 {name=p5 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 930 1100 0 0 {name=p6 lab=HI}
C {devices/lab_pin.sym} 930 1120 0 0 {name=p7 lab=LO}
C {devices/lab_pin.sym} 930 1070 0 0 {name=p8 lab=EN_VIN_BSTR_N}
C {devices/lab_pin.sym} 930 1020 0 0 {name=p9 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 930 1040 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1270 1100 0 0 {name=p32 lab=HI}
C {devices/lab_pin.sym} 1270 1120 0 0 {name=p33 lab=LO}
C {devices/lab_pin.sym} 1270 1070 0 0 {name=p34 lab=EN_VIN_BSTR_N}
C {devices/lab_pin.sym} 1270 1020 0 0 {name=p35 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 1270 1040 0 0 {name=p37 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1610 1100 0 0 {name=p38 lab=HI}
C {devices/lab_pin.sym} 1610 1120 0 0 {name=p39 lab=LO}
C {devices/lab_pin.sym} 1610 1070 0 0 {name=p40 lab=EN_VIN_BSTR_N}
C {devices/lab_pin.sym} 1610 1020 0 0 {name=p41 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 1610 1040 0 0 {name=p43 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1950 1100 0 0 {name=p44 lab=HI}
C {devices/lab_pin.sym} 1950 1120 0 0 {name=p45 lab=LO}
C {devices/lab_pin.sym} 1950 1070 0 0 {name=p46 lab=EN_VIN_BSTR_N}
C {devices/lab_pin.sym} 1950 1020 0 0 {name=p47 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 1950 1040 0 0 {name=p49 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 1100 0 0 {name=p50 lab=HI}
C {devices/lab_pin.sym} 2290 1120 0 0 {name=p51 lab=LO}
C {devices/lab_pin.sym} 2290 1070 0 0 {name=p52 lab=EN_VIN_BSTR_N}
C {devices/lab_pin.sym} 2290 1020 0 0 {name=p53 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 2290 1040 0 0 {name=p55 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2630 1100 0 0 {name=p56 lab=HI}
C {devices/lab_pin.sym} 2630 1120 0 0 {name=p57 lab=LO}
C {devices/lab_pin.sym} 2630 1070 0 0 {name=p58 lab=EN_VIN_BSTR_N}
C {devices/lab_pin.sym} 2630 1020 0 0 {name=p59 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 2630 1040 0 0 {name=p61 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2970 1100 0 0 {name=p62 lab=HI}
C {devices/lab_pin.sym} 2970 1120 0 0 {name=p63 lab=LO}
C {devices/lab_pin.sym} 2970 1070 0 0 {name=p64 lab=EN_VIN_BSTR_N}
C {devices/lab_pin.sym} 2970 1020 0 0 {name=p65 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 2970 1040 0 0 {name=p67 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3310 1100 0 0 {name=p68 lab=HI}
C {devices/lab_pin.sym} 3310 1120 0 0 {name=p69 lab=LO}
C {devices/lab_pin.sym} 3310 1070 0 0 {name=p70 lab=EN_VIN_BSTR_N}
C {devices/lab_pin.sym} 3310 1020 0 0 {name=p71 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 3310 1040 0 0 {name=p74 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3650 1100 0 0 {name=p76 lab=HI}
C {devices/lab_pin.sym} 3650 1120 0 0 {name=p82 lab=LO}
C {devices/lab_pin.sym} 3650 1070 0 0 {name=p83 lab=EN_VIN_BSTR_N}
C {devices/lab_pin.sym} 3650 1020 0 0 {name=p84 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 3650 1040 0 0 {name=p85 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3990 1100 0 0 {name=p87 lab=HI}
C {devices/lab_pin.sym} 3990 1120 0 0 {name=p88 lab=LO}
C {devices/lab_pin.sym} 3990 1070 0 0 {name=p89 lab=EN_VIN_BSTR_N}
C {devices/lab_pin.sym} 3990 1020 0 0 {name=p90 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 3990 1040 0 0 {name=p91 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4330 1100 0 0 {name=p93 lab=HI}
C {devices/lab_pin.sym} 4330 1120 0 0 {name=p94 lab=LO}
C {devices/lab_pin.sym} 4330 1070 0 0 {name=p95 lab=LO}
C {devices/lab_pin.sym} 4330 1020 0 0 {name=p96 sig_type=std_logic lab=EN_VCM_SW}
C {devices/lab_pin.sym} 4330 1040 0 0 {name=p97 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 250 540 2 1 {name=p99 lab=HI}
C {devices/lab_pin.sym} 250 520 2 1 {name=p100 lab=LO}
C {devices/lab_pin.sym} 250 570 2 1 {name=p101 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 250 620 2 1 {name=p102 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 250 600 2 1 {name=p103 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 590 540 2 1 {name=p105 lab=HI}
C {devices/lab_pin.sym} 590 520 2 1 {name=p106 lab=LO}
C {devices/lab_pin.sym} 590 570 2 1 {name=p107 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 590 620 2 1 {name=p108 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 590 600 2 1 {name=p109 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 930 540 2 1 {name=p111 lab=HI}
C {devices/lab_pin.sym} 930 520 2 1 {name=p112 lab=LO}
C {devices/lab_pin.sym} 930 570 2 1 {name=p113 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 930 620 2 1 {name=p114 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 930 600 2 1 {name=p115 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1270 540 2 1 {name=p117 lab=HI}
C {devices/lab_pin.sym} 1270 520 2 1 {name=p118 lab=LO}
C {devices/lab_pin.sym} 1270 570 2 1 {name=p119 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 1270 620 2 1 {name=p120 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 1270 600 2 1 {name=p121 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1610 540 2 1 {name=p123 lab=HI}
C {devices/lab_pin.sym} 1610 520 2 1 {name=p124 lab=LO}
C {devices/lab_pin.sym} 1610 570 2 1 {name=p125 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 1610 620 2 1 {name=p126 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 1610 600 2 1 {name=p127 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1950 540 2 1 {name=p129 lab=HI}
C {devices/lab_pin.sym} 1950 520 2 1 {name=p130 lab=LO}
C {devices/lab_pin.sym} 1950 570 2 1 {name=p131 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 1950 620 2 1 {name=p132 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 1950 600 2 1 {name=p133 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 540 2 1 {name=p135 lab=HI}
C {devices/lab_pin.sym} 2290 520 2 1 {name=p136 lab=LO}
C {devices/lab_pin.sym} 2290 570 2 1 {name=p137 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 2290 620 2 1 {name=p138 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 2290 600 2 1 {name=p139 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2630 540 2 1 {name=p141 lab=HI}
C {devices/lab_pin.sym} 2630 520 2 1 {name=p142 lab=LO}
C {devices/lab_pin.sym} 2630 570 2 1 {name=p143 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 2630 620 2 1 {name=p144 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 2630 600 2 1 {name=p145 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2970 540 2 1 {name=p149 lab=HI}
C {devices/lab_pin.sym} 2970 520 2 1 {name=p150 lab=LO}
C {devices/lab_pin.sym} 2970 570 2 1 {name=p155 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 2970 620 2 1 {name=p156 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 2970 600 2 1 {name=p157 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3310 540 2 1 {name=p158 lab=HI}
C {devices/lab_pin.sym} 3310 520 2 1 {name=p159 lab=LO}
C {devices/lab_pin.sym} 3310 570 2 1 {name=p161 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 3310 620 2 1 {name=p162 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 3310 600 2 1 {name=p163 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3650 540 2 1 {name=p164 lab=HI}
C {devices/lab_pin.sym} 3650 520 2 1 {name=p165 lab=LO}
C {devices/lab_pin.sym} 3650 570 2 1 {name=p166 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 3650 620 2 1 {name=p167 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 3650 600 2 1 {name=p168 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3990 540 2 1 {name=p169 lab=HI}
C {devices/lab_pin.sym} 3990 520 2 1 {name=p170 lab=LO}
C {devices/lab_pin.sym} 3990 570 2 1 {name=p171 lab=EN_VIN_BSTR_P}
C {devices/lab_pin.sym} 3990 620 2 1 {name=p172 sig_type=std_logic lab=EN_VCM}
C {devices/lab_pin.sym} 3990 600 2 1 {name=p173 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4330 540 2 1 {name=p174 lab=HI}
C {devices/lab_pin.sym} 4330 520 2 1 {name=p175 lab=LO}
C {devices/lab_pin.sym} 4330 570 2 1 {name=p176 lab=LO}
C {devices/lab_pin.sym} 4330 620 2 1 {name=p177 sig_type=std_logic lab=EN_VCM_SW}
C {devices/lab_pin.sym} 4330 600 2 1 {name=p178 sig_type=std_logic lab=VSS}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/bootstrap/bootstrap.sym} 1420 -160 0 0 {name=x28}
C {devices/lab_pin.sym} 1060 -190 0 0 {name=p77 sig_type=std_logic lab=SMPL}
C {devices/lab_pin.sym} 1340 -160 0 0 {name=p179 sig_type=std_logic lab=VIN_P}
C {devices/lab_wire.sym} 1420 -120 2 0 {name=p180 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1420 -220 0 1 {name=p181 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1500 -190 0 1 {name=p182 sig_type=std_logic lab=SMPL_ON_P}
C {devices/lab_pin.sym} 1500 -160 0 1 {name=p183 sig_type=std_logic lab=EN_VIN_BSTR_P}
C {/Users/ricardonunes/Desktop/SAR_ADC_12b/bootstrap/bootstrap.sym} 1420 30 0 0 {name=x29}
C {devices/lab_pin.sym} 1340 30 0 0 {name=p184 sig_type=std_logic lab=VIN_N}
C {devices/lab_wire.sym} 1420 70 2 0 {name=p185 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1420 -30 0 1 {name=p186 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1500 0 0 1 {name=p187 sig_type=std_logic lab=SMPL_ON_N}
C {devices/lab_pin.sym} 1500 30 0 1 {name=p188 sig_type=std_logic lab=EN_VIN_BSTR_N}
C {sky130_stdcells/dlymetal6s6s_1.sym} 1115 -380 0 0 {name=x48 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dlymetal6s6s_1.sym} 1195 -380 0 0 {name=x35 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_16.sym} 920 60 0 0 {name=x1 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 880 60 0 0 {name=p189 sig_type=std_logic lab=SMPL_ON_P}
C {devices/lab_pin.sym} 960 60 2 0 {name=p190 sig_type=std_logic lab=EN_VCM}
C {devices/vsource.sym} 320 130 0 0 {name=V8 value=1.8 savecurrent=true}
C {devices/lab_wire.sym} 320 160 2 1 {name=p25 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 320 100 0 0 {name=p26 sig_type=std_logic lab=HI}
C {devices/vsource.sym} 460 130 0 0 {name=V9 value=0 savecurrent=false}
C {devices/lab_wire.sym} 460 160 2 1 {name=p191 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 460 100 0 0 {name=p192 sig_type=std_logic lab=LO}
C {devices/vsource.sym} 580 130 0 0 {name=V10 value=0 savecurrent=false}
C {devices/lab_wire.sym} 580 160 2 1 {name=p193 sig_type=std_logic lab=EN_VCM_SW}
C {devices/lab_wire.sym} 580 100 0 0 {name=p194 sig_type=std_logic lab=SMPL}
C {devices/vsource.sym} 740 -90 0 0 {name=V11 value="pulse(0 1.8 19n 100p 100p 6n 100n)" savecurrent=false}
C {devices/lab_wire.sym} 740 -60 2 1 {name=p195 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 740 -120 0 0 {name=p196 sig_type=std_logic lab=MEAS_INPUT}
C {devices/lab_wire.sym} 1075 -380 0 0 {name=p197 sig_type=std_logic lab=VSS}
