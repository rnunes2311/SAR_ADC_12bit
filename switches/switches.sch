v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -2440 -300 -2440 -240 {
lab=VIN}
N -2660 -300 -2440 -300 {
lab=VIN}
N -2660 -320 -2400 -320 {
lab=VREF}
N -2660 -340 -2360 -340 {
lab=VREF_GND}
N -2320 -360 -2320 -240 {
lab=VCM}
N -2660 -360 -2320 -360 {
lab=VCM}
N -2440 -300 -2100 -300 {
lab=VIN}
N -2100 -300 -2100 -240 {
lab=VIN}
N -2400 -320 -2060 -320 {
lab=VREF}
N -2060 -320 -2060 -240 {
lab=VREF}
N -2020 -340 -2020 -240 {
lab=VREF_GND}
N -2360 -340 -2020 -340 {
lab=VREF_GND}
N -1980 -360 -1980 -240 {
lab=VCM}
N -2320 -360 -1980 -360 {
lab=VCM}
N -2100 -300 -1760 -300 {
lab=VIN}
N -1760 -300 -1760 -240 {
lab=VIN}
N -2060 -320 -1720 -320 {
lab=VREF}
N -1720 -320 -1720 -240 {
lab=VREF}
N -1680 -340 -1680 -240 {
lab=VREF_GND}
N -2020 -340 -1680 -340 {
lab=VREF_GND}
N -1640 -360 -1640 -240 {
lab=VCM}
N -1980 -360 -1640 -360 {
lab=VCM}
N -1760 -300 -1420 -300 {
lab=VIN}
N -1420 -300 -1420 -240 {
lab=VIN}
N -1720 -320 -1380 -320 {
lab=VREF}
N -1380 -320 -1380 -240 {
lab=VREF}
N -1340 -340 -1340 -240 {
lab=VREF_GND}
N -1680 -340 -1340 -340 {
lab=VREF_GND}
N -1300 -360 -1300 -240 {
lab=VCM}
N -1640 -360 -1300 -360 {
lab=VCM}
N -1420 -300 -1080 -300 {
lab=VIN}
N -1080 -300 -1080 -240 {
lab=VIN}
N -1380 -320 -1040 -320 {
lab=VREF}
N -1040 -320 -1040 -240 {
lab=VREF}
N -1000 -340 -1000 -240 {
lab=VREF_GND}
N -1340 -340 -1000 -340 {
lab=VREF_GND}
N -960 -360 -960 -240 {
lab=VCM}
N -1300 -360 -960 -360 {
lab=VCM}
N -1080 -300 -740 -300 {
lab=VIN}
N -740 -300 -740 -240 {
lab=VIN}
N -1040 -320 -700 -320 {
lab=VREF}
N -700 -320 -700 -240 {
lab=VREF}
N -660 -340 -660 -240 {
lab=VREF_GND}
N -1000 -340 -660 -340 {
lab=VREF_GND}
N -620 -360 -620 -240 {
lab=VCM}
N -960 -360 -620 -360 {
lab=VCM}
N -740 -300 -400 -300 {
lab=VIN}
N -400 -300 -400 -240 {
lab=VIN}
N -700 -320 -360 -320 {
lab=VREF}
N -360 -320 -360 -240 {
lab=VREF}
N -320 -340 -320 -240 {
lab=VREF_GND}
N -660 -340 -320 -340 {
lab=VREF_GND}
N -280 -360 -280 -240 {
lab=VCM}
N -620 -360 -280 -360 {
lab=VCM}
N -400 -300 -60 -300 {
lab=VIN}
N -60 -300 -60 -240 {
lab=VIN}
N -360 -320 -20 -320 {
lab=VREF}
N -20 -320 -20 -240 {
lab=VREF}
N 20 -340 20 -240 {
lab=VREF_GND}
N -320 -340 20 -340 {
lab=VREF_GND}
N 60 -360 60 -240 {
lab=VCM}
N -280 -360 60 -360 {
lab=VCM}
N -60 -300 280 -300 {
lab=VIN}
N 280 -300 280 -240 {
lab=VIN}
N -20 -320 320 -320 {
lab=VREF}
N 320 -320 320 -240 {
lab=VREF}
N 360 -340 360 -240 {
lab=VREF_GND}
N 20 -340 360 -340 {
lab=VREF_GND}
N 400 -360 400 -240 {
lab=VCM}
N 60 -360 400 -360 {
lab=VCM}
N 280 -300 620 -300 {
lab=VIN}
N 620 -300 620 -240 {
lab=VIN}
N 320 -320 660 -320 {
lab=VREF}
N 660 -320 660 -240 {
lab=VREF}
N 700 -340 700 -240 {
lab=VREF_GND}
N 360 -340 700 -340 {
lab=VREF_GND}
N 740 -360 740 -240 {
lab=VCM}
N 400 -360 740 -360 {
lab=VCM}
N 620 -300 960 -300 {
lab=VIN}
N 960 -300 960 -240 {
lab=VIN}
N 660 -320 1000 -320 {
lab=VREF}
N 1000 -320 1000 -240 {
lab=VREF}
N 1040 -340 1040 -240 {
lab=VREF_GND}
N 700 -340 1040 -340 {
lab=VREF_GND}
N 1080 -360 1080 -240 {
lab=VCM}
N 740 -360 1080 -360 {
lab=VCM}
N 960 -300 1300 -300 {
lab=VIN}
N 1300 -300 1300 -240 {
lab=VIN}
N 1000 -320 1340 -320 {
lab=VREF}
N 1340 -320 1340 -240 {
lab=VREF}
N 1380 -340 1380 -240 {
lab=VREF_GND}
N 1040 -340 1380 -340 {
lab=VREF_GND}
N 1420 -360 1420 -240 {
lab=VCM}
N 1080 -360 1420 -360 {
lab=VCM}
N 1760 -360 1760 -240 {
lab=VCM}
N 1420 -360 1760 -360 {
lab=VCM}
N -2360 -100 -2360 -80 {
lab=Cbtm_0_dummy}
N -2020 -100 -2020 -80 {
lab=Cbtm_0}
N -1680 -100 -1680 -80 {
lab=Cbtm_1}
N -1340 -100 -1340 -80 {
lab=Cbtm_2}
N -1000 -100 -1000 -80 {
lab=Cbtm_3}
N -660 -100 -660 -80 {
lab=Cbtm_4}
N -320 -100 -320 -80 {
lab=Cbtm_5}
N 20 -100 20 -80 {
lab=Cbtm_6}
N 360 -100 360 -80 {
lab=Cbtm_7}
N 700 -100 700 -80 {
lab=Cbtm_8}
N 1040 -100 1040 -80 {
lab=Cbtm_9}
N 1380 -100 1380 -80 {
lab=Cbtm_10}
N 1720 -100 1720 -80 {
lab=VDAC}
N -2650 100 -2440 100 {
lab=VDD}
N -2660 100 -2650 100 {
lab=VDD}
N -2100 -100 -2100 100 {
lab=VDD}
N -2440 100 -2100 100 {
lab=VDD}
N -1760 -100 -1760 100 {
lab=VDD}
N -2100 100 -1760 100 {
lab=VDD}
N -1420 -100 -1420 100 {
lab=VDD}
N -1760 100 -1420 100 {
lab=VDD}
N -1080 -100 -1080 100 {
lab=VDD}
N -1420 100 -1080 100 {
lab=VDD}
N -740 -100 -740 100 {
lab=VDD}
N -1080 100 -740 100 {
lab=VDD}
N -400 -100 -400 100 {
lab=VDD}
N -740 100 -400 100 {
lab=VDD}
N -60 -100 -60 100 {
lab=VDD}
N -400 100 -60 100 {
lab=VDD}
N 280 -100 280 100 {
lab=VDD}
N -60 100 280 100 {
lab=VDD}
N 620 -100 620 100 {
lab=VDD}
N 280 100 620 100 {
lab=VDD}
N 960 -100 960 100 {
lab=VDD}
N 620 100 960 100 {
lab=VDD}
N 1300 -100 1300 100 {
lab=VDD}
N 960 100 1300 100 {
lab=VDD}
N 1640 -100 1640 100 {
lab=VDD}
N 1300 100 1640 100 {
lab=VDD}
C {devices/ipin.sym} -2660 -360 0 0 {name=p1 lab=VCM}
C {devices/ipin.sym} -2660 -340 0 0 {name=p2 lab=VREF_GND}
C {devices/ipin.sym} -2660 -320 0 0 {name=p3 lab=VREF}
C {devices/ipin.sym} -2660 -300 0 0 {name=p4 lab=VIN}
C {devices/ipin.sym} -2660 100 0 0 {name=p5 lab=VDD}
C {devices/opin.sym} -2360 -80 1 0 {name=p6 lab=Cbtm_0_dummy}
C {devices/opin.sym} -2020 -80 1 0 {name=p7 lab=Cbtm_0}
C {devices/opin.sym} -1680 -80 1 0 {name=p9 lab=Cbtm_1}
C {devices/opin.sym} -1340 -80 1 0 {name=p10 lab=Cbtm_2}
C {devices/opin.sym} -1000 -80 1 0 {name=p11 lab=Cbtm_3}
C {devices/opin.sym} -660 -80 1 0 {name=p12 lab=Cbtm_4}
C {devices/opin.sym} -320 -80 1 0 {name=p13 lab=Cbtm_5}
C {devices/opin.sym} 20 -80 1 0 {name=p14 lab=Cbtm_6}
C {devices/opin.sym} 360 -80 1 0 {name=p15 lab=Cbtm_7}
C {devices/opin.sym} 700 -80 1 0 {name=p16 lab=Cbtm_8}
C {devices/opin.sym} 1040 -80 1 0 {name=p17 lab=Cbtm_9}
C {devices/opin.sym} 1380 -80 1 0 {name=p18 lab=Cbtm_10}
C {devices/opin.sym} 1720 -80 1 0 {name=p8 lab=VDAC}
C {devices/ipin.sym} -2660 -200 0 0 {name=p19 lab=EN_VIN}
C {devices/ipin.sym} -2660 -160 0 0 {name=p20 lab=EN_VREF_Z[10:0]}
C {devices/ipin.sym} -2660 -140 0 0 {name=p21 lab=EN_VSS[10:0]}
C {devices/ipin.sym} -2660 -120 0 0 {name=p22 lab=EN_VCM[10:0]}
C {devices/lab_pin.sym} -2500 -200 0 0 {name=p23 sig_type=std_logic lab=EN_VIN}
C {devices/ipin.sym} -2500 -120 0 0 {name=p25 lab=EN_VCM_DUMMY}
C {devices/lab_pin.sym} -2160 -200 0 0 {name=p27 sig_type=std_logic lab=EN_VIN}
C {devices/lab_pin.sym} -2160 -160 0 0 {name=p28 sig_type=std_logic lab=EN_VREF_Z[0]}
C {devices/lab_pin.sym} -2160 -140 0 0 {name=p29 sig_type=std_logic lab=EN_VSS[0]}
C {devices/lab_pin.sym} -2160 -120 0 0 {name=p30 sig_type=std_logic lab=EN_VCM[0]}
C {devices/lab_pin.sym} -1820 -200 0 0 {name=p31 sig_type=std_logic lab=EN_VIN}
C {devices/lab_pin.sym} -1820 -160 0 0 {name=p32 sig_type=std_logic lab=EN_VREF_Z[1]}
C {devices/lab_pin.sym} -1820 -140 0 0 {name=p33 sig_type=std_logic lab=EN_VSS[1]}
C {devices/lab_pin.sym} -1820 -120 0 0 {name=p34 sig_type=std_logic lab=EN_VCM[1]}
C {devices/lab_pin.sym} -1480 -200 0 0 {name=p35 sig_type=std_logic lab=EN_VIN}
C {devices/lab_pin.sym} -1480 -160 0 0 {name=p36 sig_type=std_logic lab=EN_VREF_Z[2]}
C {devices/lab_pin.sym} -1480 -140 0 0 {name=p37 sig_type=std_logic lab=EN_VSS[2]}
C {devices/lab_pin.sym} -1480 -120 0 0 {name=p38 sig_type=std_logic lab=EN_VCM[2]}
C {devices/lab_pin.sym} -1140 -200 0 0 {name=p39 sig_type=std_logic lab=EN_VIN}
C {devices/lab_pin.sym} -1140 -160 0 0 {name=p40 sig_type=std_logic lab=EN_VREF_Z[3]}
C {devices/lab_pin.sym} -1140 -140 0 0 {name=p41 sig_type=std_logic lab=EN_VSS[3]}
C {devices/lab_pin.sym} -1140 -120 0 0 {name=p42 sig_type=std_logic lab=EN_VCM[3]}
C {devices/lab_pin.sym} -800 -200 0 0 {name=p43 sig_type=std_logic lab=EN_VIN}
C {devices/lab_pin.sym} -800 -160 0 0 {name=p44 sig_type=std_logic lab=EN_VREF_Z[4]}
C {devices/lab_pin.sym} -800 -140 0 0 {name=p45 sig_type=std_logic lab=EN_VSS[4]}
C {devices/lab_pin.sym} -800 -120 0 0 {name=p46 sig_type=std_logic lab=EN_VCM[4]}
C {devices/lab_pin.sym} -460 -200 0 0 {name=p47 sig_type=std_logic lab=EN_VIN}
C {devices/lab_pin.sym} -460 -160 0 0 {name=p48 sig_type=std_logic lab=EN_VREF_Z[5]}
C {devices/lab_pin.sym} -460 -140 0 0 {name=p49 sig_type=std_logic lab=EN_VSS[5]}
C {devices/lab_pin.sym} -460 -120 0 0 {name=p50 sig_type=std_logic lab=EN_VCM[5]}
C {devices/lab_pin.sym} -120 -200 0 0 {name=p51 sig_type=std_logic lab=EN_VIN}
C {devices/lab_pin.sym} -120 -160 0 0 {name=p52 sig_type=std_logic lab=EN_VREF_Z[6]}
C {devices/lab_pin.sym} -120 -140 0 0 {name=p53 sig_type=std_logic lab=EN_VSS[6]}
C {devices/lab_pin.sym} -120 -120 0 0 {name=p54 sig_type=std_logic lab=EN_VCM[6]}
C {devices/lab_pin.sym} 220 -200 0 0 {name=p55 sig_type=std_logic lab=EN_VIN}
C {devices/lab_pin.sym} 220 -160 0 0 {name=p56 sig_type=std_logic lab=EN_VREF_Z[7]}
C {devices/lab_pin.sym} 220 -140 0 0 {name=p57 sig_type=std_logic lab=EN_VSS[7]}
C {devices/lab_pin.sym} 220 -120 0 0 {name=p58 sig_type=std_logic lab=EN_VCM[7]}
C {devices/lab_pin.sym} 560 -200 0 0 {name=p59 sig_type=std_logic lab=EN_VIN}
C {devices/lab_pin.sym} 560 -160 0 0 {name=p60 sig_type=std_logic lab=EN_VREF_Z[8]}
C {devices/lab_pin.sym} 560 -140 0 0 {name=p61 sig_type=std_logic lab=EN_VSS[8]}
C {devices/lab_pin.sym} 560 -120 0 0 {name=p62 sig_type=std_logic lab=EN_VCM[8]}
C {devices/lab_pin.sym} 900 -200 0 0 {name=p63 sig_type=std_logic lab=EN_VIN}
C {devices/lab_pin.sym} 900 -160 0 0 {name=p64 sig_type=std_logic lab=EN_VREF_Z[9]}
C {devices/lab_pin.sym} 900 -140 0 0 {name=p65 sig_type=std_logic lab=EN_VSS[9]}
C {devices/lab_pin.sym} 900 -120 0 0 {name=p66 sig_type=std_logic lab=EN_VCM[9]}
C {devices/lab_pin.sym} 1240 -200 0 0 {name=p67 sig_type=std_logic lab=EN_VIN}
C {devices/lab_pin.sym} 1240 -160 0 0 {name=p68 sig_type=std_logic lab=EN_VREF_Z[10]}
C {devices/lab_pin.sym} 1240 -140 0 0 {name=p69 sig_type=std_logic lab=EN_VSS[10]}
C {devices/lab_pin.sym} 1240 -120 0 0 {name=p70 sig_type=std_logic lab=EN_VCM[10]}
C {devices/ipin.sym} 1580 -120 0 0 {name=p71 lab=EN_VCM_SW}
C {individual_switches/switch_VCM.sym} 1700 -160 2 1 {name=x1}
C {individual_switches/switch_C10.sym} 1360 -160 2 1 {name=x2}
C {individual_switches/switch_C9.sym} 1020 -160 2 1 {name=x3}
C {individual_switches/switch_C8.sym} 680 -160 2 1 {name=x4}
C {individual_switches/switch_C7.sym} 340 -160 2 1 {name=x5}
C {individual_switches/switch_C6.sym} 0 -160 2 1 {name=x6}
C {individual_switches/switch_C5.sym} -340 -160 2 1 {name=x7}
C {individual_switches/switch_C5.sym} -680 -160 2 1 {name=x8}
C {individual_switches/switch_C5.sym} -1020 -160 2 1 {name=x9}
C {individual_switches/switch_C5.sym} -1360 -160 2 1 {name=x10}
C {individual_switches/switch_C5.sym} -1700 -160 2 1 {name=x11}
C {individual_switches/switch_C5.sym} -2040 -160 2 1 {name=x12}
C {individual_switches/switch_C0_dummy.sym} -2380 -160 2 1 {name=x13}
C {devices/ipin.sym} -2660 120 0 0 {name=p24 lab=VSS}
C {devices/lab_pin.sym} 1440 -200 0 1 {name=p26 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1780 -200 0 1 {name=p72 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1100 -200 0 1 {name=p73 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 760 -200 0 1 {name=p74 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 420 -200 0 1 {name=p75 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 80 -200 0 1 {name=p76 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -260 -200 0 1 {name=p77 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -600 -200 0 1 {name=p78 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -940 -200 0 1 {name=p79 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1280 -200 0 1 {name=p80 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 -200 0 1 {name=p81 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1960 -200 0 1 {name=p82 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -2300 -200 0 1 {name=p83 sig_type=std_logic lab=VSS}
